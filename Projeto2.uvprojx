# Keil uVision project Projeto2.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Projeto2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./: main.c lcdio.c teclado.c subRotinaAdm.c teclado.h lcdio.h timers.c timers.h controle_motor.c controle_motor.h menus.c menus.h rotinas_viagem.c rotinas_viagem.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.5.0
